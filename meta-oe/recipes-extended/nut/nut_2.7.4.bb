require ${PN}.inc

SRC_URI = "http://www.networkupstools.org/source/2.7/${PN}-${PV}.tar.gz"

SRC_URI[md5sum] = "3ba53656933d7471f95140b32a5b8d5c"
SRC_URI[sha256sum] = "980e82918c52d364605c0703a5dcf01f74ad2ef06e3d365949e43b7d406d25a7"
